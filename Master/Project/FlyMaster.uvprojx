# Keil uVision project FlyMaster.uvprojx, settings and files
target Master (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.1.0.5
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: FlyMaster +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER,STM32F10X_HD
  c include: ..\Drvers\Librarise\CMSIS;..\Drvers\Librarise\STM32F10x_StdPeriph_Driver\inc;..\User;..\Drvers;..\Middlewares\FreeRTOS\include;..\Middlewares\FreeRTOS\portable;..\Middlewares\FreeRTOS;..\IMU;..\Com;..\APP;..\..\Master
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group User
    ../User/: main.c stm32f10x_it.c freertos_demo.c
  group Startup
    ../Drvers/Librarise/CMSIS/: startup_stm32f10x_hd.s
  group StdPeriph_Driver
    ../Drvers/Librarise/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../Drvers/Librarise/CMSIS/: core_cm3.c system_stm32f10x.c
  group Driver/BSP
    ../Drvers/BSP/LED/: led.c
    ../Drvers/BSP/IIC/: iic.c
    ../Drvers/BSP/MPU-6050/: mpu6050.c
    ../Drvers/BSP/MOTOR/: motor.c
    ../Drvers/BSP/SPI/: spi.c
    ../Drvers/BSP/SI24R/: si24r.c
    ../Drvers/BSP/EXIT/: exit.c
    ../Drvers/BSP/TIME/: time4.c
  group Drvier/SYSTEM
    ../Drvers/SYSTEM/system/: system.c
    ../Drvers/SYSTEM/systick/: systick.c
    ../Drvers/SYSTEM/usart/: usart.c
  group Middlewares/FreeRTOS_CORE
    ../Middlewares/FreeRTOS/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
  group Middlewares/FreeRTOS_PORT
    ../Middlewares/FreeRTOS/portable/: heap_4.c port.c
  group IMU
    ../IMU/: filtering.c imu.c
  group COM
    ../Com/: com_ano.c
  group APP
    ../APP/REMOTE/: remotedata.c
  group Contrl
    ../Contrl/PID/: pid.c
    ../Contrl/CTRL/: ctrl.c
